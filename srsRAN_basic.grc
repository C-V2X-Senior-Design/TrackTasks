options:
  parameters:
    generate_options: qt_gui
    id: srsRAN_basic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: slider
    type: complex
  states: {state: disabled}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', zeromq_rep_sink_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', zeromq_rep_sink_0_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [zeromq_req_source_0_0, '0', digital_mpsk_snr_est_cc_0_0, '0']

metadata:
  file_format: 1
